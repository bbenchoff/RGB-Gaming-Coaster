File: LEDboard.sch (EAGLE design)
At the start: 304 parts, among them IC1 REG1117, U1 IS31FL3741_QFN60, U2 IS31FL3741_QFN60, U3 ATSAMD21E, U4 TPS61090RSAR, U5 MCP73831T-2ACI/OT, Y1 32.768kHz

Commit message: all parts placed?
Parts:
- added C10, C14, C16, C8: 1uF, rcl:C-EUC0805K
- added C13, C15, C7, C9: 0.1uF, rcl:C-EUC0805K
- added R73, R75: 10k, rcl:R-US_R0805
- added R74, R76: 10k, rcl:R-EU_R0805
- renumbered IC1 to VREG
Connections:
- new net N$80: R73.2, U1.RSET
- new net N$82: R74.1, U1.SDB
- new net N$83: R75.2, U2.RSET
- new net N$84: R76.1, U2.SDB
- new net SCL: U1.SCL, U2.SCL, U3.PA23
- new net SDA: U1.SDA, U2.SDA, U3.PA22
- new net VCC: C10.1, C13.1, C14.1, C15.1, C16.1, C7.1, C8.1, C9.1, U1.AVCC, U1.PVCC1, U1.PVCC2, U2.AVCC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
- net 3V3: now also R74.2, R76.2
- net GND: now also C10.2, C13.2, C14.2, C15.2, C16.2, C7.2, C8.2, C9.2, R73.1, R75.1, U1.ADDR, U1.GND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

Commit message: Added jtag, power
Parts:
- removed C1: 1uF, microbuilder:CAP_CERAMIC0805-NOOUTLINE
- removed C2: 0.1uF, microbuilder:CAP_CERAMIC0805-NOOUTLINE
- added J1: JTAG, SparkFun-Connectors:CORTEX_DEBUG_SMD
Connections:
- removed net N$77: C2.2, U3.VDD
- net 3V3: now also J1.VCC, U3.VCORE, U3.VDD; no longer C1.1, C2.1
- net GND: no longer U3.GND
- net N$75: now also J1.GND@3, J1.GND@5, U3.GND; no longer C1.2, U3.VCORE
- net RESET: now also J1.!RESET
- net SWCLK: now also J1.SWDCLK/TCK
- net SWDIO: now also J1.SWDIO/TMS
Changed lines of the file:
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@@
 <part name="U3" library="adafruit" deviceset="ATSAMD21E" device=""/>
 <part name="U$6" library="microbuilder" deviceset="5.0V" device="" value="3V3"/>
-<part name="C1" library="microbuilder" deviceset="CAP_CERAMIC" device="0805-NOOUTLINE" value="1uF"/>
 <part name="U$9" library="microbuilder" deviceset="GND" device=""/>
-<part name="C2" library="microbuilder" deviceset="CAP_CERAMIC" device="0805-NOOUTLINE" value="0.1uF"/>
 <part name="Y1" library="SparkFun-Clocks" library_urn="urn:adsk.eagle:library:511" deviceset="CRYSTAL-32.768KHZ" device="SMD-3.2X1.5" package3d_urn="urn:adsk.eagle:package:37548/1" value="32.768kHz"/>
 <part name="U$11" library="microbuilder" deviceset="GND" device=""/>
@@
 <part name="R76" library="rcl" library_urn="urn:adsk.eagle:library:334" deviceset="R-EU_" device="R0805" package3d_urn="urn:adsk.eagle:package:23553/2" value="10k"/>
 <part name="+3V1" library="supply1" library_urn="urn:adsk.eagle:library:371" deviceset="+3V3" device=""/>
+<part name="J1" library="SparkFun-Connectors" library_urn="urn:adsk.eagle:library:513" deviceset="CORTEX_DEBUG" device="_SMD" package3d_urn="urn:adsk.eagle:package:38289/1" value="JTAG"/>
+<part name="U$4" library="microbuilder" deviceset="5.0V" device="" value="3V3"/>
+<part name="U$14" library="microbuilder" deviceset="GND" device=""/>
 </parts>
 <sheets>
@@
 <attribute name="VALUE" x="21.336" y="82.296" size="1.27" layer="96"/>
 </instance>
-<instance part="C1" gate="G$1" x="27.94" y="66.04" smashed="yes" rot="R90">
-<attribute name="NAME" x="26.69" y="63.75" size="1.27" layer="95" font="vector" rot="R180" align="center"/>
-<attribute name="VALUE" x="26.69" y="68.34" size="1.27" layer="96" font="vector" rot="R180" align="center"/>
-</instance>
 <instance part="U$9" gate="G$1" x="22.86" y="10.16" smashed="yes">
 <attribute name="VALUE" x="21.336" y="7.62" size="1.27" layer="96"/>
 </instance>
-<instance part="C2" gate="G$1" x="30.48" y="71.12" smashed="yes" rot="R90">
-<attribute name="NAME" x="29.23" y="68.83" size="1.27" layer="95" font="vector" rot="R180" align="center"/>
-<attribute name="VALUE" x="29.23" y="73.42" size="1.27" layer="96" font="vector" rot="R180" align="center"/>
-</instance>
 <instance part="Y1" gate="G$1" x="78.74" y="50.8" smashed="yes" rot="R180">
 <attribute name="NAME" x="78.74" y="48.768" size="1.778" layer="95" font="vector" rot="R180" align="bottom-center"/>
@@
 <attribute name="VALUE" x="84.836" y="41.529" size="1.778" layer="96"/>
 </instance>
+<instance part="J1" gate="G$1" x="-17.78" y="48.26" smashed="yes">
+<attribute name="NAME" x="-30.48" y="56.134" size="1.778" layer="95" font="vector"/>
+<attribute name="VALUE" x="-30.48" y="38.354" size="1.778" layer="96" font="vector"/>
+</instance>
+<instance part="U$4" gate="G$1" x="-35.56" y="60.96" smashed="yes">
+<attribute name="VALUE" x="-37.084" y="61.976" size="1.27" layer="96"/>
+</instance>
+<instance part="U$14" gate="G$1" x="-43.18" y="12.7" smashed="yes">
+<attribute name="VALUE" x="-44.704" y="10.16" size="1.27" layer="96"/>
+</instance>
 </instances>
 <busses>
@@
 <wire x1="22.86" y1="73.66" x2="22.86" y2="78.74" width="0.1524" layer="91"/>
 <wire x1="22.86" y1="71.12" x2="22.86" y2="73.66" width="0.1524" layer="91"/>
-<pinref part="C1" gate="G$1" pin="1"/>
 <wire x1="22.86" y1="66.04" x2="22.86" y2="71.12" width="0.1524" layer="91"/>
-<pinref part="C2" gate="G$1" pin="1"/>
 <wire x1="25.4" y1="71.12" x2="22.86" y2="71.12" width="0.1524" layer="91"/>
 <junction x="22.86" y="71.12"/>
-</segment>
-</net>
-<net name="N$75" class="0">
-<segment>
+<pinref part="U3" gate="G$1" pin="VDD"/>
+<wire x1="25.4" y1="71.12" x2="33.02" y2="71.12" width="0.1524" layer="91"/>
 <pinref part="U3" gate="G$1" pin="VCORE"/>
-<pinref part="C1" gate="G$1" pin="2"/>
 <wire x1="33.02" y1="66.04" x2="30.48" y2="66.04" width="0.1524" layer="91"/>
+<wire x1="22.86" y1="66.04" x2="30.48" y2="66.04" width="0.1524" layer="91"/>
 </segment>
-</net>
-<net name="GND" class="0">
 <segment>
-<wire x1="22.86" y1="15.24" x2="22.86" y2="12.7" width="0.1524" layer="91"/>
-<pinref part="U$9" gate="G$1" pin="GND"/>
-<pinref part="U3" gate="G$1" pin="GND"/>
-<wire x1="33.02" y1="15.24" x2="22.86" y2="15.24" width="0.1524" layer="91"/>
+<pinref part="U$4" gate="G$1" pin="5.0V"/>
+<wire x1="-35.56" y1="53.34" x2="-35.56" y2="58.42" width="0.1524" layer="91"/>
+<pinref part="J1" gate="G$1" pin="VCC"/>
+<wire x1="-33.02" y1="53.34" x2="-35.56" y2="53.34" width="0.1524" layer="91"/>
 </segment>
+</net>
+<net name="GND" class="0">
 <segment>
 <wire x1="78.74" y1="40.64" x2="78.74" y2="38.1" width="0.1524" layer="91"/>
@@
 </segment>
 </net>
-<net name="N$77" class="0">
-<segment>
-<pinref part="C2" gate="G$1" pin="2"/>
-<pinref part="U3" gate="G$1" pin="VDD"/>
-</segment>
-</net>
 <net name="N$78" class="0">
 <segment>
@@
 <label x="17.78" y="30.48" size="1.778" layer="95"/>
 </segment>
+<segment>
+<pinref part="J1" gate="G$1" pin="!RESET"/>
+<wire x1="0" y1="43.18" x2="15.24" y2="43.18" width="0.1524" layer="91"/>
+<label x="7.62" y="43.18" size="1.778" layer="95"/>
+</segment>
 </net>
 <net name="SWDIO" class="0">
@@
 <label x="17.78" y="25.4" size="1.778" layer="95"/>
 </segment>
+<segment>
+<wire x1="0" y1="53.34" x2="15.24" y2="53.34" width="0.1524" layer="91"/>
+<label x="15.24" y="53.34" size="1.778" layer="95" rot="R180"/>
+<pinref part="J1" gate="G$1" pin="SWDIO/TMS"/>
+</segment>
 </net>
 <net name="SWCLK" class="0">
@@
 <label x="17.78" y="22.86" size="1.778" layer="95"/>
 </segment>
+<segment>
+<wire x1="0" y1="50.8" x2="15.24" y2="50.8" width="0.1524" layer="91"/>
+<label x="15.24" y="50.8" size="1.778" layer="95" rot="R180"/>
+<pinref part="J1" gate="G$1" pin="SWDCLK/TCK"/>
+</segment>
 </net>
 <net name="SDA" class="0">
@@
 </segment>
 </net>
+<net name="N$75" class="0">
+<segment>
+<pinref part="J1" gate="G$1" pin="GND@3"/>
+<wire x1="-33.02" y1="50.8" x2="-43.18" y2="50.8" width="0.1524" layer="91"/>
+<wire x1="-43.18" y1="50.8" x2="-43.18" y2="48.26" width="0.1524" layer="91"/>
+<pinref part="J1" gate="G$1" pin="GND@5"/>
+<wire x1="-43.18" y1="48.26" x2="-43.18" y2="17.78" width="0.1524" layer="91"/>
+<wire x1="-33.02" y1="48.26" x2="-43.18" y2="48.26" width="0.1524" layer="91"/>
+<junction x="-43.18" y="48.26"/>
+<wire x1="22.86" y1="15.24" x2="22.86" y2="12.7" width="0.1524" layer="91"/>
+<pinref part="U$9" gate="G$1" pin="GND"/>
+<pinref part="U3" gate="G$1" pin="GND"/>
+<wire x1="33.02" y1="15.24" x2="22.86" y2="15.24" width="0.1524" layer="91"/>
+<wire x1="-43.18" y1="17.78" x2="-43.18" y2="15.24" width="0.1524" layer="91"/>
+<pinref part="U$14" gate="G$1" pin="GND"/>
+<wire x1="22.86" y1="15.24" x2="-43.18" y2="15.24" width="0.1524" layer="91"/>
+<junction x="22.86" y="15.24"/>
+<junction x="-43.18" y="15.24"/>
+</segment>
+</net>

Commit message: rotate
did something
Connections:
- removed net VCC: C10.1, C13.1, C14.1, C15.1, C16.1, C7.1, C8.1, C9.1, U1.AVCC, U1.PVCC1, U1.PVCC2, U2.AVCC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
- net 5.0V: now also C10.1, C13.1, C14.1, C15.1, C16.1, C7.1, C8.1, C9.1, U1.AVCC, U1.PVCC1, U1.PVCC2, U2.AVCC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
- net N$75: now also J1.GNDDTCT
Changed lines of the file:
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@@
 </segment>
 </net>
-<net name="VCC" class="0">
+<net name="5.0V" class="0">
 <segment>
 <wire x1="200.66" y1="360.68" x2="200.66" y2="370.84" width="0.1524" layer="91"/>
@@
 </segment>
 </net>
-<net name="VCC" class="0">
+<net name="5.0V" class="0">
 <segment>
 <wire x1="38.1" y1="223.52" x2="38.1" y2="233.68" width="0.1524" layer="91"/>
@@
 <wire x1="-43.18" y1="50.8" x2="-43.18" y2="48.26" width="0.1524" layer="91"/>
 <pinref part="J1" gate="G$1" pin="GND@5"/>
-<wire x1="-43.18" y1="48.26" x2="-43.18" y2="17.78" width="0.1524" layer="91"/>
+<wire x1="-43.18" y1="48.26" x2="-43.18" y2="43.18" width="0.1524" layer="91"/>
+<wire x1="-43.18" y1="43.18" x2="-43.18" y2="17.78" width="0.1524" layer="91"/>
 <wire x1="-33.02" y1="48.26" x2="-43.18" y2="48.26" width="0.1524" layer="91"/>
 <junction x="-43.18" y="48.26"/>
@@
 <junction x="22.86" y="15.24"/>
 <junction x="-43.18" y="15.24"/>
+<pinref part="J1" gate="G$1" pin="GNDDTCT"/>
+<wire x1="-33.02" y1="43.18" x2="-43.18" y2="43.18" width="0.1524" layer="91"/>
+<junction x="-43.18" y="43.18"/>
 </segment>
 </net>

Commit message: Added jumper 0ohm resistor
Parts:
- added R77: 0 Ohm, SparkFun-Resistors:RESISTOR1206
- added S1: TAC_SWITCHSMD, SparkFun-Retired:TAC_SWITCHSMD
Connections:
- net 5.0V: now also R77.1, R77.2
Other:
- note added: "Fix the address things"
Changed lines of the file:
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@@
 <part name="U$4" library="microbuilder" deviceset="5.0V" device="" value="3V3"/>
 <part name="U$14" library="microbuilder" deviceset="GND" device=""/>
+<part name="S1" library="SparkFun-Retired" library_urn="urn:adsk.eagle:library:533" deviceset="TAC_SWITCH" device="SMD" value="TAC_SWITCHSMD"/>
+<part name="R77" library="SparkFun-Resistors" library_urn="urn:adsk.eagle:library:532" deviceset="RESISTOR" device="1206" package3d_urn="urn:adsk.eagle:package:39654/1" value="0 Ohm"/>
+<part name="U$15" library="microbuilder" deviceset="5.0V" device=""/>
+<part name="U$16" library="microbuilder" deviceset="5.0V" device=""/>
 </parts>
 <sheets>
@@
 <wire x1="170.18" y1="-101.6" x2="167.64" y2="-99.06" width="0.1524" layer="94"/>
 <text x="-129.54" y="241.3" size="19.05" layer="94">LED Array Right</text>
+<text x="-5.08" y="139.7" size="5.08" layer="91">Fix the address things</text>
 </plain>
 <instances>
@@
 <attribute name="VALUE" x="-44.704" y="10.16" size="1.27" layer="96"/>
 </instance>
+<instance part="S1" gate="S" x="88.9" y="73.66" smashed="yes">
+<attribute name="NAME" x="86.36" y="80.01" size="1.778" layer="95"/>
+<attribute name="VALUE" x="86.36" y="67.31" size="1.778" layer="96"/>
+</instance>
 </instances>
 <busses>
@@
 <attribute name="VALUE" x="49.276" y="107.696" size="1.27" layer="96"/>
 </instance>
+<instance part="R77" gate="G$1" x="12.7" y="88.9" smashed="yes">
+<attribute name="NAME" x="12.7" y="90.424" size="1.778" layer="95" font="vector" align="bottom-center"/>
+<attribute name="VALUE" x="12.7" y="87.376" size="1.778" layer="96" font="vector" align="top-center"/>
+</instance>
+<instance part="U$15" gate="G$1" x="7.62" y="96.52" smashed="yes">
+<attribute name="VALUE" x="6.096" y="97.536" size="1.27" layer="96"/>
+</instance>
+<instance part="U$16" gate="G$1" x="17.78" y="96.52" smashed="yes">
+<attribute name="VALUE" x="16.256" y="97.536" size="1.27" layer="96"/>
+</instance>
 </instances>
 <busses>
@@
 <wire x1="22.86" y1="99.06" x2="20.32" y2="99.06" width="0.1524" layer="91"/>
 </segment>
+<segment>
+<pinref part="U$15" gate="G$1" pin="5.0V"/>
+<wire x1="7.62" y1="88.9" x2="7.62" y2="93.98" width="0.1524" layer="91"/>
+<pinref part="R77" gate="G$1" pin="1"/>
+</segment>
+<segment>
+<pinref part="U$16" gate="G$1" pin="5.0V"/>
+<wire x1="17.78" y1="88.9" x2="17.78" y2="93.98" width="0.1524" layer="91"/>
+<pinref part="R77" gate="G$1" pin="2"/>
+</segment>
 </net>

Commit message: Ground fill / button
Parts:
- added R78, R83, R84: 0 Ohm, SparkFun-Resistors:RESISTOR1206
- added R85: 340k, microbuilder:RESISTOR0805_NOOUTLINE
- added R87: 200K, microbuilder:RESISTOR0805_NOOUTLINE
- added U$20: TINDIE_SWITCH, TindieBadge:ALPSSLIDESW
Connections:
- new net ENABLE: R85.1, U$20.1, U4.EN
- new net N$77: R84.1, U3.PA23
- new net N$85: R87.1, S1.1, S1.2, U3.PA15
- net 3V3: now also R87.2
- net GND: now also J1.GND@3, J1.GND@5, J1.GNDDTCT, R78.1, R78.2, S1.3, S1.4, U$20.2, U3.GND
- net N$75: now also R83.1, U3.PA22; no longer J1.GND@3, J1.GND@5, J1.GNDDTCT, U3.GND
- net SCL: now also R84.2; no longer U3.PA23
- net SDA: now also R83.2; no longer U3.PA22
- net VBAT: now also R85.2; no longer U4.EN
Other:
- note added: "PA15/D5"
- moved on the sheet: S1
