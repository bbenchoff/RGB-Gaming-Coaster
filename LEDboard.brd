# Repository bbenchoff/RGB-Gaming-Coaster (continued)

## EAGLE design LEDboard.brd (continued)

Parts:
C13, C15: 0.1uF; C0805K
C14, C16: 1uF; C0805K
LED1-2-1, LED1-2-2, LED1-2-3, LED1-2-4, LED1-2-5, LED1-2-6, LED1-2-7, LED1-2-8, LED1-2-9, LED1-2-10, LED1-2-11, LED1-2-12, LED1-2-13, LED1-2-14, LED1-2-15, LED1-2-16, LED1-2-17, LED1-2-18, LED1-2-19, LED1-2-20, LED1-2-21, LED1-2-22, LED1-2-23, LED2-2-1, LED2-2-2, LED2-2-3, LED2-2-4, LED2-2-5, LED2-2-6, LED2-2-7, LED2-2-8, LED2-2-9, LED2-2-10, LED2-2-11, LED2-2-12, LED2-2-13, LED2-2-14, LED2-2-15, LED2-2-16, LED2-2-17, LED2-2-18, LED2-2-19, LED2-2-20, LED3-2-1, LED3-2-2, LED3-2-3, LED3-2-4, LED3-2-5, LED3-2-6, LED3-2-7, LED3-2-8, LED3-2-9, LED3-2-10, LED3-2-11, LED3-2-12, LED3-2-13, LED3-2-14, LED3-2-15, LED3-2-16, LED3-2-17, LED4-2-1, LED4-2-2, LED4-2-3, LED4-2-4, LED4-2-5, LED4-2-6, LED4-2-7, LED4-2-8, LED4-2-9, LED4-2-10, LED4-2-11, LED4-2-12, LED4-2-13, LED4-2-14, LED5-2-1, LED5-2-2, LED5-2-3, LED5-2-4, LED5-2-5, LED5-2-6, LED5-2-7, LED5-2-8, LED5-2-9, LED5-2-10, LED5-2-11, LED5-2-12, LED6-2-1, LED6-2-2, LED6-2-3, LED6-2-4, LED6-2-5, LED6-2-6, LED6-2-7, LED6-2-8, LED6-2-9, LED7-2-1, LED7-2-2, LED7-2-3, LED7-2-4, LED7-2-5, LED7-2-6, LED7-2-7, LED8-2-1, LED8-2-2, LED8-2-3: IN-B101FCH; SMD-4
R37, R40, R43, R46, R49, R52, R55, R58, R61, R64, R67, R70: 51Ω; 0603
R38, R39, R41, R42, R44, R45, R47, R48, R50, R51, R53, R54, R56, R57, R59, R60, R62, R63, R65, R66, R68, R69, R71, R72: 20Ω; 0603
R75, R76: 10k; R0805
U2: IS31FL3741_QFN60; QFN60

Connections:
3V3: R76.2, U2.8 (ADDR); also elsewhere on the board
5.0V: C13.1, C14.1, C15.1, C16.1, U2.14 (AVCC), U2.15 (PVCC1), U2.25 (PVCC2); also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, R75.1, U2.12 (GND), U2.36 (GND), U2.55 (GND), U2.PAD (GND); also elsewhere on the board
unnamed: R37.1, U2.6 (CS39)
unnamed: R38.1, U2.5 (CS38)
unnamed: R39.1, U2.4 (CS37)
unnamed: R40.1, U2.3 (CS36)
unnamed: R41.1, U2.2 (CS35)
unnamed: R42.1, U2.1 (CS34)
unnamed: R43.1, U2.60 (CS33)
unnamed: R44.1, U2.59 (CS32)
unnamed: R45.1, U2.58 (CS31)
unnamed: R46.1, U2.57 (CS30)
unnamed: R47.1, U2.56 (CS29)
unnamed: R48.1, U2.54 (CS28)
unnamed: R49.1, U2.53 (CS27)
unnamed: R50.1, U2.52 (CS26)
unnamed: R51.1, U2.51 (CS25)
unnamed: R52.1, U2.50 (CS24)
unnamed: R53.1, U2.49 (CS23)
unnamed: R54.1, U2.48 (CS22)
unnamed: R55.1, U2.47 (CS21)
unnamed: R56.1, U2.46 (CS20)
unnamed: R57.1, U2.45 (CS19)
unnamed: R58.1, U2.44 (CS18)
unnamed: R59.1, U2.43 (CS17)
unnamed: R60.1, U2.42 (CS16)
unnamed: R61.1, U2.41 (CS15)
unnamed: R62.1, U2.40 (CS14)
unnamed: R63.1, U2.39 (CS13)
unnamed: R64.1, U2.38 (CS12)
unnamed: R65.1, U2.37 (CS11)
unnamed: R66.1, U2.35 (CS10)
unnamed: R67.1, U2.34 (CS9)
unnamed: R68.1, U2.33 (CS8)
unnamed: R69.1, U2.32 (CS7)
unnamed: R70.1, U2.31 (CS6)
unnamed: R71.1, U2.30 (CS5)
unnamed: R72.1, U2.29 (CS4)
unnamed: R75.2, U2.13 (RSET)
unnamed: R76.1, U2.11 (SDB)
SCL: U2.10 (SCL); also elsewhere on the board
SDA: U2.9 (SDA); also elsewhere on the board
U2CS4: LED7-2-5.PIN3 (GRN), LED7-2-6.PIN3 (GRN), LED7-2-7.PIN3 (GRN), LED8-2-1.PIN3 (GRN), LED8-2-2.PIN3 (GRN), LED8-2-3.PIN3 (GRN), R72.2
U2CS5: LED7-2-5.PIN4 (BLU), LED7-2-6.PIN4 (BLU), LED7-2-7.PIN4 (BLU), LED8-2-1.PIN4 (BLU), LED8-2-2.PIN4 (BLU), LED8-2-3.PIN4 (BLU), R71.2
U2CS6: LED7-2-5.PIN2 (RED), LED7-2-6.PIN2 (RED), LED7-2-7.PIN2 (RED), LED8-2-1.PIN2 (RED), LED8-2-2.PIN2 (RED), LED8-2-3.PIN2 (RED), R70.2
U2CS7: LED6-2-1.PIN3 (GRN), LED6-2-2.PIN3 (GRN), LED6-2-3.PIN3 (GRN), LED6-2-4.PIN3 (GRN), LED6-2-5.PIN3 (GRN), LED7-2-1.PIN3 (GRN), LED7-2-2.PIN3 (GRN), LED7-2-3.PIN3 (GRN), LED7-2-4.PIN3 (GRN), R69.2
U2CS8: LED6-2-1.PIN4 (BLU), LED6-2-2.PIN4 (BLU), LED6-2-3.PIN4 (BLU), LED6-2-4.PIN4 (BLU), LED6-2-5.PIN4 (BLU), LED7-2-1.PIN4 (BLU), LED7-2-2.PIN4 (BLU), LED7-2-3.PIN4 (BLU), LED7-2-4.PIN4 (BLU), R68.2
U2CS9: LED6-2-1.PIN2 (RED), LED6-2-2.PIN2 (RED), LED6-2-3.PIN2 (RED), LED6-2-4.PIN2 (RED), LED6-2-5.PIN2 (RED), LED7-2-1.PIN2 (RED), LED7-2-2.PIN2 (RED), LED7-2-3.PIN2 (RED), LED7-2-4.PIN2 (RED), R67.2
U2CS10: LED5-2-8.PIN3 (GRN), LED5-2-9.PIN3 (GRN), LED5-2-10.PIN3 (GRN), LED5-2-11.PIN3 (GRN), LED5-2-12.PIN3 (GRN), LED6-2-6.PIN3 (GRN), LED6-2-7.PIN3 (GRN), LED6-2-8.PIN3 (GRN), LED6-2-9.PIN3 (GRN), R66.2
U2CS11: LED5-2-8.PIN4 (BLU), LED5-2-9.PIN4 (BLU), LED5-2-10.PIN4 (BLU), LED5-2-11.PIN4 (BLU), LED5-2-12.PIN4 (BLU), LED6-2-6.PIN4 (BLU), LED6-2-7.PIN4 (BLU), LED6-2-8.PIN4 (BLU), LED6-2-9.PIN4 (BLU), R65.2
U2CS12: LED5-2-8.PIN2 (RED), LED5-2-9.PIN2 (RED), LED5-2-10.PIN2 (RED), LED5-2-11.PIN2 (RED), LED5-2-12.PIN2 (RED), LED6-2-6.PIN2 (RED), LED6-2-7.PIN2 (RED), LED6-2-8.PIN2 (RED), LED6-2-9.PIN2 (RED), R64.2
U2CS13: LED4-2-1.PIN3 (GRN), LED4-2-2.PIN3 (GRN), LED5-2-1.PIN3 (GRN), LED5-2-2.PIN3 (GRN), LED5-2-3.PIN3 (GRN), LED5-2-4.PIN3 (GRN), LED5-2-5.PIN3 (GRN), LED5-2-6.PIN3 (GRN), LED5-2-7.PIN3 (GRN), R63.2
U2CS14: LED4-2-1.PIN4 (BLU), LED4-2-2.PIN4 (BLU), LED5-2-1.PIN4 (BLU), LED5-2-2.PIN4 (BLU), LED5-2-3.PIN4 (BLU), LED5-2-4.PIN4 (BLU), LED5-2-5.PIN4 (BLU), LED5-2-6.PIN4 (BLU), LED5-2-7.PIN4 (BLU), R62.2
U2CS15: LED4-2-1.PIN2 (RED), LED4-2-2.PIN2 (RED), LED5-2-1.PIN2 (RED), LED5-2-2.PIN2 (RED), LED5-2-3.PIN2 (RED), LED5-2-4.PIN2 (RED), LED5-2-5.PIN2 (RED), LED5-2-6.PIN2 (RED), LED5-2-7.PIN2 (RED), R61.2
U2CS16: LED4-2-3.PIN3 (GRN), LED4-2-4.PIN3 (GRN), LED4-2-5.PIN3 (GRN), LED4-2-6.PIN3 (GRN), LED4-2-7.PIN3 (GRN), LED4-2-8.PIN3 (GRN), LED4-2-9.PIN3 (GRN), LED4-2-10.PIN3 (GRN), LED4-2-11.PIN3 (GRN), R60.2
U2CS17: LED4-2-3.PIN4 (BLU), LED4-2-4.PIN4 (BLU), LED4-2-5.PIN4 (BLU), LED4-2-6.PIN4 (BLU), LED4-2-7.PIN4 (BLU), LED4-2-8.PIN4 (BLU), LED4-2-9.PIN4 (BLU), LED4-2-10.PIN4 (BLU), LED4-2-11.PIN4 (BLU), R59.2
U2CS18: LED4-2-3.PIN2 (RED), LED4-2-4.PIN2 (RED), LED4-2-5.PIN2 (RED), LED4-2-6.PIN2 (RED), LED4-2-7.PIN2 (RED), LED4-2-8.PIN2 (RED), LED4-2-9.PIN2 (RED), LED4-2-10.PIN2 (RED), LED4-2-11.PIN2 (RED), R58.2
U2CS19: LED3-2-12.PIN3 (GRN), LED3-2-13.PIN3 (GRN), LED3-2-14.PIN3 (GRN), LED3-2-15.PIN3 (GRN), LED3-2-16.PIN3 (GRN), LED3-2-17.PIN3 (GRN), LED4-2-12.PIN3 (GRN), LED4-2-13.PIN3 (GRN), LED4-2-14.PIN3 (GRN), R57.2
U2CS20: LED3-2-12.PIN4 (BLU), LED3-2-13.PIN4 (BLU), LED3-2-14.PIN4 (BLU), LED3-2-15.PIN4 (BLU), LED3-2-16.PIN4 (BLU), LED3-2-17.PIN4 (BLU), LED4-2-12.PIN4 (BLU), LED4-2-13.PIN4 (BLU), LED4-2-14.PIN4 (BLU), R56.2
U2CS21: LED3-2-12.PIN2 (RED), LED3-2-13.PIN2 (RED), LED3-2-14.PIN2 (RED), LED3-2-15.PIN2 (RED), LED3-2-16.PIN2 (RED), LED3-2-17.PIN2 (RED), LED4-2-12.PIN2 (RED), LED4-2-13.PIN2 (RED), LED4-2-14.PIN2 (RED), R55.2
U2CS22: LED3-2-3.PIN3 (GRN), LED3-2-4.PIN3 (GRN), LED3-2-5.PIN3 (GRN), LED3-2-6.PIN3 (GRN), LED3-2-7.PIN3 (GRN), LED3-2-8.PIN3 (GRN), LED3-2-9.PIN3 (GRN), LED3-2-10.PIN3 (GRN), LED3-2-11.PIN3 (GRN), R54.2
U2CS23: LED3-2-3.PIN4 (BLU), LED3-2-4.PIN4 (BLU), LED3-2-5.PIN4 (BLU), LED3-2-6.PIN4 (BLU), LED3-2-7.PIN4 (BLU), LED3-2-8.PIN4 (BLU), LED3-2-9.PIN4 (BLU), LED3-2-10.PIN4 (BLU), LED3-2-11.PIN4 (BLU), R53.2
U2CS24: LED3-2-3.PIN2 (RED), LED3-2-4.PIN2 (RED), LED3-2-5.PIN2 (RED), LED3-2-6.PIN2 (RED), LED3-2-7.PIN2 (RED), LED3-2-8.PIN2 (RED), LED3-2-9.PIN2 (RED), LED3-2-10.PIN2 (RED), LED3-2-11.PIN2 (RED), R52.2
U2CS25: LED2-2-1.PIN3 (GRN), LED2-2-2.PIN3 (GRN), LED2-2-3.PIN3 (GRN), LED2-2-4.PIN3 (GRN), LED2-2-5.PIN3 (GRN), LED2-2-6.PIN3 (GRN), LED2-2-7.PIN3 (GRN), LED3-2-1.PIN3 (GRN), LED3-2-2.PIN3 (GRN), R51.2
U2CS26: LED2-2-1.PIN4 (BLU), LED2-2-2.PIN4 (BLU), LED2-2-3.PIN4 (BLU), LED2-2-4.PIN4 (BLU), LED2-2-5.PIN4 (BLU), LED2-2-6.PIN4 (BLU), LED2-2-7.PIN4 (BLU), LED3-2-1.PIN4 (BLU), LED3-2-2.PIN4 (BLU), R50.2
U2CS27: LED2-2-1.PIN2 (RED), LED2-2-2.PIN2 (RED), LED2-2-3.PIN2 (RED), LED2-2-4.PIN2 (RED), LED2-2-5.PIN2 (RED), LED2-2-6.PIN2 (RED), LED2-2-7.PIN2 (RED), LED3-2-1.PIN2 (RED), LED3-2-2.PIN2 (RED), R49.2
U2CS28: LED2-2-8.PIN3 (GRN), LED2-2-9.PIN3 (GRN), LED2-2-10.PIN3 (GRN), LED2-2-11.PIN3 (GRN), LED2-2-12.PIN3 (GRN), LED2-2-13.PIN3 (GRN), LED2-2-14.PIN3 (GRN), LED2-2-15.PIN3 (GRN), LED2-2-16.PIN3 (GRN), R48.2
U2CS29: LED2-2-8.PIN4 (BLU), LED2-2-9.PIN4 (BLU), LED2-2-10.PIN4 (BLU), LED2-2-11.PIN4 (BLU), LED2-2-12.PIN4 (BLU), LED2-2-13.PIN4 (BLU), LED2-2-14.PIN4 (BLU), LED2-2-15.PIN4 (BLU), LED2-2-16.PIN4 (BLU), R47.2
U2CS30: LED2-2-8.PIN2 (RED), LED2-2-9.PIN2 (RED), LED2-2-10.PIN2 (RED), LED2-2-11.PIN2 (RED), LED2-2-12.PIN2 (RED), LED2-2-13.PIN2 (RED), LED2-2-14.PIN2 (RED), LED2-2-15.PIN2 (RED), LED2-2-16.PIN2 (RED), R46.2
U2CS31: LED1-2-19.PIN3 (GRN), LED1-2-20.PIN3 (GRN), LED1-2-21.PIN3 (GRN), LED1-2-22.PIN3 (GRN), LED1-2-23.PIN3 (GRN), LED2-2-17.PIN3 (GRN), LED2-2-18.PIN3 (GRN), LED2-2-19.PIN3 (GRN), LED2-2-20.PIN3 (GRN), R45.2
U2CS32: LED1-2-19.PIN4 (BLU), LED1-2-20.PIN4 (BLU), LED1-2-21.PIN4 (BLU), LED1-2-22.PIN4 (BLU), LED1-2-23.PIN4 (BLU), LED2-2-17.PIN4 (BLU), LED2-2-18.PIN4 (BLU), LED2-2-19.PIN4 (BLU), LED2-2-20.PIN4 (BLU), R44.2
U2CS33: LED1-2-19.PIN2 (RED), LED1-2-20.PIN2 (RED), LED1-2-21.PIN2 (RED), LED1-2-22.PIN2 (RED), LED1-2-23.PIN2 (RED), LED2-2-17.PIN2 (RED), LED2-2-18.PIN2 (RED), LED2-2-19.PIN2 (RED), LED2-2-20.PIN2 (RED), R43.2
U2CS34: LED1-2-10.PIN3 (GRN), LED1-2-11.PIN3 (GRN), LED1-2-12.PIN3 (GRN), LED1-2-13.PIN3 (GRN), LED1-2-14.PIN3 (GRN), LED1-2-15.PIN3 (GRN), LED1-2-16.PIN3 (GRN), LED1-2-17.PIN3 (GRN), LED1-2-18.PIN3 (GRN), R42.2
U2CS35: LED1-2-10.PIN4 (BLU), LED1-2-11.PIN4 (BLU), LED1-2-12.PIN4 (BLU), LED1-2-13.PIN4 (BLU), LED1-2-14.PIN4 (BLU), LED1-2-15.PIN4 (BLU), LED1-2-16.PIN4 (BLU), LED1-2-17.PIN4 (BLU), LED1-2-18.PIN4 (BLU), R41.2
U2CS36: LED1-2-10.PIN2 (RED), LED1-2-11.PIN2 (RED), LED1-2-12.PIN2 (RED), LED1-2-13.PIN2 (RED), LED1-2-14.PIN2 (RED), LED1-2-15.PIN2 (RED), LED1-2-16.PIN2 (RED), LED1-2-17.PIN2 (RED), LED1-2-18.PIN2 (RED), R40.2
U2CS37: LED1-2-1.PIN3 (GRN), LED1-2-2.PIN3 (GRN), LED1-2-3.PIN3 (GRN), LED1-2-4.PIN3 (GRN), LED1-2-5.PIN3 (GRN), LED1-2-6.PIN3 (GRN), LED1-2-7.PIN3 (GRN), LED1-2-8.PIN3 (GRN), LED1-2-9.PIN3 (GRN), R39.2
U2CS38: LED1-2-1.PIN4 (BLU), LED1-2-2.PIN4 (BLU), LED1-2-3.PIN4 (BLU), LED1-2-4.PIN4 (BLU), LED1-2-5.PIN4 (BLU), LED1-2-6.PIN4 (BLU), LED1-2-7.PIN4 (BLU), LED1-2-8.PIN4 (BLU), LED1-2-9.PIN4 (BLU), R38.2
U2CS39: LED1-2-1.PIN2 (RED), LED1-2-2.PIN2 (RED), LED1-2-3.PIN2 (RED), LED1-2-4.PIN2 (RED), LED1-2-5.PIN2 (RED), LED1-2-6.PIN2 (RED), LED1-2-7.PIN2 (RED), LED1-2-8.PIN2 (RED), LED1-2-9.PIN2 (RED), R37.2
U2SW1: LED1-2-1.PIN1 (A), LED1-2-10.PIN1 (A), LED1-2-19.PIN1 (A), LED2-2-7.PIN1 (A), LED2-2-16.PIN1 (A), LED3-2-3.PIN1 (A), LED3-2-12.PIN1 (A), LED4-2-2.PIN1 (A), LED4-2-11.PIN1 (A), LED5-2-8.PIN1 (A), LED6-2-5.PIN1 (A), LED7-2-5.PIN1 (A), U2.16 (SW1)
U2SW2: LED1-2-2.PIN1 (A), LED1-2-11.PIN1 (A), LED1-2-20.PIN1 (A), LED2-2-6.PIN1 (A), LED2-2-15.PIN1 (A), LED3-2-4.PIN1 (A), LED3-2-13.PIN1 (A), LED4-2-1.PIN1 (A), LED4-2-10.PIN1 (A), LED5-2-9.PIN1 (A), LED6-2-4.PIN1 (A), LED7-2-6.PIN1 (A), U2.17 (SW2)
U2SW3: LED1-2-3.PIN1 (A), LED1-2-12.PIN1 (A), LED1-2-21.PIN1 (A), LED2-2-5.PIN1 (A), LED2-2-14.PIN1 (A), LED3-2-5.PIN1 (A), LED3-2-14.PIN1 (A), LED4-2-9.PIN1 (A), LED5-2-1.PIN1 (A), LED5-2-10.PIN1 (A), LED6-2-3.PIN1 (A), LED7-2-7.PIN1 (A), U2.18 (SW3)
U2SW4: LED1-2-4.PIN1 (A), LED1-2-13.PIN1 (A), LED1-2-22.PIN1 (A), LED2-2-4.PIN1 (A), LED2-2-13.PIN1 (A), LED3-2-6.PIN1 (A), LED3-2-15.PIN1 (A), LED4-2-8.PIN1 (A), LED5-2-2.PIN1 (A), LED5-2-11.PIN1 (A), LED6-2-2.PIN1 (A), LED8-2-3.PIN1 (A), U2.19 (SW4)
U2SW5: LED1-2-5.PIN1 (A), LED1-2-14.PIN1 (A), LED1-2-23.PIN1 (A), LED2-2-3.PIN1 (A), LED2-2-12.PIN1 (A), LED3-2-7.PIN1 (A), LED3-2-16.PIN1 (A), LED4-2-7.PIN1 (A), LED5-2-3.PIN1 (A), LED5-2-12.PIN1 (A), LED6-2-1.PIN1 (A), LED8-2-2.PIN1 (A), U2.20 (SW5)
U2SW6: LED1-2-6.PIN1 (A), LED1-2-15.PIN1 (A), LED2-2-2.PIN1 (A), LED2-2-11.PIN1 (A), LED2-2-20.PIN1 (A), LED3-2-8.PIN1 (A), LED3-2-17.PIN1 (A), LED4-2-6.PIN1 (A), LED5-2-4.PIN1 (A), LED6-2-9.PIN1 (A), LED7-2-1.PIN1 (A), LED8-2-1.PIN1 (A), U2.21 (SW6)
U2SW7: LED1-2-7.PIN1 (A), LED1-2-16.PIN1 (A), LED2-2-1.PIN1 (A), LED2-2-10.PIN1 (A), LED2-2-19.PIN1 (A), LED3-2-9.PIN1 (A), LED4-2-5.PIN1 (A), LED4-2-14.PIN1 (A), LED5-2-5.PIN1 (A), LED6-2-8.PIN1 (A), LED7-2-2.PIN1 (A), U2.22 (SW7)
U2SW8: LED1-2-8.PIN1 (A), LED1-2-17.PIN1 (A), LED2-2-9.PIN1 (A), LED2-2-18.PIN1 (A), LED3-2-1.PIN1 (A), LED3-2-10.PIN1 (A), LED4-2-4.PIN1 (A), LED4-2-13.PIN1 (A), LED5-2-6.PIN1 (A), LED6-2-7.PIN1 (A), LED7-2-3.PIN1 (A), U2.23 (SW8)
U2SW9: LED1-2-9.PIN1 (A), LED1-2-18.PIN1 (A), LED2-2-8.PIN1 (A), LED2-2-17.PIN1 (A), LED3-2-2.PIN1 (A), LED3-2-11.PIN1 (A), LED4-2-3.PIN1 (A), LED4-2-12.PIN1 (A), LED5-2-7.PIN1 (A), LED6-2-6.PIN1 (A), LED7-2-4.PIN1 (A), U2.24 (SW9)

Notes on the sheet:
LED Array Right
ADDR connects to vcc ADDR = 11 See pg. 7 of datasheet

Parts:
C3, C4: 10pF; C0805
J1: JTAG; SAMTECH_FTSH-105-01
R78, R83: 200K; 0805-NO
S2, S3: KMS221GLFS
U3: ATSAMD21E; TQFP32-08
Y1: 32.768kHz; CRYSTAL-SMD-3.2X1.5MM

Connections:
3V3: J1.1 (VCC), R78.2, R83.2, U3.9 (VDD), U3.30 (VDD); also elsewhere on the board
GND: C3.2, C4.2, J1.3 (GND), J1.5 (GND), J1.9 (GNDDTCT), S2.1 (NO_1), S2.5 (NO_2), S3.1 (NO_1), S3.5 (NO_2), U3.10 (GND), U3.28 (GND); also elsewhere on the board
unnamed: C4.1, U3.2 (PA1), Y1.P$1 (1)
unnamed: C3.1, U3.1 (PA0), Y1.P$2 (2)
PA6/D8: R83.1, S3.2 (COM_1), U3.7 (PA6)
PA15/D5: R78.1, S2.2 (COM_1), U3.16 (PA15)
RESET: J1.10 (!RESET), U3.26 (RESET)
SCL: U3.22 (PA23); also elsewhere on the board
SDA: U3.21 (PA22); also elsewhere on the board
SWCLK: J1.4 (SWDCLK/TCK), U3.31 (SWCLK)
SWDIO: J1.2 (SWDIO/TMS), U3.32 (SWDIO)
USB_N: U3.23 (D-); also elsewhere on the board
USB_P: U3.24 (D+); also elsewhere on the board

Notes on the sheet:
PA15/D5

Parts:
B1: S2B-PH-SM4-TB(LF)(SN); JSTPH2
C5: 100uF/6V; EIA3528-21/B-R
C6: 10µF; 0805-NO
J2: USB_MICRO-B_FEMALE-SMT; USB-B-MICRO-SMD
L1: VLC5045-6.8uH; INDUCTOR_5X5MM_TDK_VLC5045
R79, R82: 1.87Mohm; 0805-NO
R80: 200K; 0805-NO
R81: 340K; 0805-NO
R85: 340k; 0805-NO
R86: 2k; 0805-NO
U4: TPS61090RSAR; PVQFN-16
U5: MCP73831T-2ACI/OT; SOT23-5
U$17: TINDIE_SWITCH; SWITCH-SSSS810701
VREG: REG1117; SOT223

Connections:
3V3: VREG.2 (VOUT); also elsewhere on the board
5.0V: C5.+, R79.2, U4.1 (VOUT), U4.15 (VOUT), U4.16 (VOUT), VREG.3 (VIN); also elsewhere on the board
ENABLE: R85.1, U4.11 (EN), U$17.1
GND: B1.1 (-), C5.-, C6.2, J2.GND, R80.1, R81.1, R86.2, U4.5 (PGND), U4.6 (PGND), U4.7 (PGND), U4.10 (SYNC), U4.13 (GND), U4.P$18 (PGND), U4.P$19 (PGND), U4.P$20 (PGND), U4.P$21 (PGND), U4.P$22 (PGND), U4.THERMAL (PGND), U5.2 (VSS), U$17.2, VREG.1 (GND); also elsewhere on the board
unnamed: L1.P$2 (2), U4.3 (SW), U4.4 (SW)
unnamed: R81.2, R82.1, U4.9 (LBI)
unnamed: R79.1, R80.2, U4.14 (FB)
unnamed: R86.1, U5.5 (PROG)
USB_N: J2.D-; also elsewhere on the board
USB_P: J2.D+; also elsewhere on the board
VBAT: B1.2 (+), L1.P$1 (1), R82.2, R85.2, U4.8 (VBAT), U5.3 (VBAT)
VDD1: C6.1, J2.VBUS, U5.4 (VDD)

Notes on the sheet:
See Pg 15 1st para
6.8uH power w/2A current
R2 < 500K R1 = 5.5*R2 (3.2V LBO)
R4 = 200K R3 = 1.85Mohm
2.0K = 500mA
With apologies to Adafruit The power circuit is a rip-off of the PowerBoost 500C

Board: 4 copper layers, 72.0 x 72.0 mm, 321 parts (110 on the bottom side), 187 nets.

## Commit log

2019-07-22 Initial
    Just the spacer plate
2019-07-23 Placed LEDs
2019-07-26 Half routing
2019-07-27 Routed other half
2019-07-27 Placed Everything
2019-07-29 Added more stuff
2019-07-30 placed power
2019-07-30 dear fucking god
2019-07-31 Remove LBO, change bypass cap
2019-07-31 holy shit one layer
2019-08-01 micro
2019-08-02 diff pair
2019-08-04 all parts placed?
2019-08-05 Added jtag, power
2019-08-05 rotate
    did something
2019-08-05 Added jumper 0ohm resistor
2019-08-06 Ground fill / button
2019-08-06 routing
2019-08-06 I think I fucked something up
2019-08-07 I need a record of me fucking up
    lol move all the resistors
2019-08-07 fixed the leds
2019-08-07 adsfasdf
2019-08-07 Resolved
2019-08-07 major routing
2019-08-18 thing
2019-08-18 merge
2019-08-24 starting on routing
2019-08-24 save
2019-08-25 dear god help me
2019-08-25 dear god
2019-08-25 jesus hell
2019-08-25 Mother of god
2019-08-26 slowly making progress
2019-08-27 It's half done
2019-08-28 Massive rewrite
2019-08-28 added more radial guide lines
2019-08-30 fuckin around
2019-09-02 Stage 1 done
2019-09-03 Layer one done
2019-09-03 another ring
2019-09-06 difficulty
2019-09-06 another row
2019-09-07 begin removal
2019-09-07 god help me
2019-09-07 revert
2019-09-08 more routing
2019-09-08 fuckall
2019-09-08 more rows
2019-09-09 another bunch
2019-09-09 finished left hand
2019-09-10 omg jesus christ
2019-09-10 Beginning the final routing
2019-09-10 one side done
2019-09-10 complete
2019-09-10 jesus fuck me it's done
2019-09-15 another update
2019-09-16 getting rid of airwires
2019-09-16 24 left
2019-09-17 dear jesus it's done
2019-09-17 Fixed address pins
2019-09-18 went through drc
2019-09-18 Start work on assembly
2019-09-18 updated bom
2019-09-19 fidex stuff
2019-09-19 added for pack plate
2019-09-21 Made back plate
2019-09-21 Updated plates
2020-04-12 Fixed tiny issue, now works
2020-04-14 updated board
2021-02-24 Added circuit Diagram
2021-02-24 Added readme
