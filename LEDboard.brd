# Repository bbenchoff/RGB-Gaming-Coaster

File README.md:

# RGB-Gaming-Coaster
An Oreo construction RGB disc sort of thing

## EAGLE design LEDboard.brd

Parts:
C7, C9: 0.1uF; C0805K
C8, C10: 1uF; C0805K
LED1-1-1, LED1-1-2, LED1-1-3, LED1-1-4, LED1-1-5, LED1-1-6, LED1-1-7, LED1-1-8, LED1-1-9, LED1-1-10, LED1-1-11, LED1-1-12, LED1-1-13, LED1-1-14, LED1-1-15, LED1-1-16, LED1-1-17, LED1-1-18, LED1-1-19, LED1-1-20, LED1-1-21, LED1-1-22, LED1-1-23, LED2-1-1, LED2-1-2, LED2-1-3, LED2-1-4, LED2-1-5, LED2-1-6, LED2-1-7, LED2-1-8, LED2-1-9, LED2-1-10, LED2-1-11, LED2-1-12, LED2-1-13, LED2-1-14, LED2-1-15, LED2-1-16, LED2-1-17, LED2-1-18, LED2-1-19, LED2-1-20, LED3-1-1, LED3-1-2, LED3-1-3, LED3-1-4, LED3-1-5, LED3-1-6, LED3-1-7, LED3-1-8, LED3-1-9, LED3-1-10, LED3-1-11, LED3-1-12, LED3-1-13, LED3-1-14, LED3-1-15, LED3-1-16, LED3-1-17, LED4-1-1, LED4-1-2, LED4-1-3, LED4-1-4, LED4-1-5, LED4-1-6, LED4-1-7, LED4-1-8, LED4-1-9, LED4-1-10, LED4-1-11, LED4-1-12, LED4-1-13, LED4-1-14, LED5-1-1, LED5-1-2, LED5-1-3, LED5-1-4, LED5-1-5, LED5-1-6, LED5-1-7, LED5-1-8, LED5-1-9, LED5-1-10, LED5-1-11, LED5-1-12, LED6-1-1, LED6-1-2, LED6-1-3, LED6-1-4, LED6-1-5, LED6-1-6, LED6-1-7, LED6-1-8, LED6-1-9, LED7-1-1, LED7-1-2, LED7-1-3, LED7-1-4, LED7-1-5, LED7-1-6, LED7-1-7, LED8-1-1, LED8-1-2, LED8-1-3, LED9-1-1: IN-B101FCH; SMD-4
R1, R4, R7, R10, R13, R16, R19, R22, R25, R28, R31, R34: 51Ω; 0603
R2, R3, R5, R6, R8, R9, R11, R12, R14, R15, R17, R18, R20, R21, R23, R24, R26, R27, R29, R30, R32, R33, R35, R36: 20Ω; 0603
R73, R74: 10k; R0805
U1: IS31FL3741_QFN60; QFN60

Connections:
3V3: R74.2; also elsewhere on the board
5.0V: C7.1, C8.1, C9.1, C10.1, U1.14 (AVCC), U1.15 (PVCC1), U1.25 (PVCC2); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, R73.1, U1.8 (ADDR), U1.12 (GND), U1.36 (GND), U1.55 (GND), U1.PAD (GND); also elsewhere on the board
unnamed: R1.1, U1.6 (CS39)
unnamed: R2.1, U1.5 (CS38)
unnamed: R3.1, U1.4 (CS37)
unnamed: R4.1, U1.3 (CS36)
unnamed: R5.1, U1.2 (CS35)
unnamed: R6.1, U1.1 (CS34)
unnamed: R7.1, U1.60 (CS33)
unnamed: R8.1, U1.59 (CS32)
unnamed: R9.1, U1.58 (CS31)
unnamed: R10.1, U1.57 (CS30)
unnamed: R11.1, U1.56 (CS29)
unnamed: R12.1, U1.54 (CS28)
unnamed: R13.1, U1.53 (CS27)
unnamed: R14.1, U1.52 (CS26)
unnamed: R15.1, U1.51 (CS25)
unnamed: R16.1, U1.50 (CS24)
unnamed: R17.1, U1.49 (CS23)
unnamed: R18.1, U1.48 (CS22)
unnamed: R19.1, U1.47 (CS21)
unnamed: R20.1, U1.46 (CS20)
unnamed: R21.1, U1.45 (CS19)
unnamed: R22.1, U1.44 (CS18)
unnamed: R23.1, U1.43 (CS17)
unnamed: R24.1, U1.42 (CS16)
unnamed: R25.1, U1.41 (CS15)
unnamed: R26.1, U1.40 (CS14)
unnamed: R27.1, U1.39 (CS13)
unnamed: R28.1, U1.38 (CS12)
unnamed: R29.1, U1.37 (CS11)
unnamed: R30.1, U1.35 (CS10)
unnamed: R31.1, U1.34 (CS9)
unnamed: R32.1, U1.33 (CS8)
unnamed: R33.1, U1.32 (CS7)
unnamed: R34.1, U1.31 (CS6)
unnamed: R35.1, U1.30 (CS5)
unnamed: R36.1, U1.29 (CS4)
unnamed: R73.2, U1.13 (RSET)
unnamed: R74.1, U1.11 (SDB)
SCL: U1.10 (SCL); also elsewhere on the board
SDA: U1.9 (SDA); also elsewhere on the board
U1CS4: LED7-1-5.PIN3 (GRN), LED7-1-6.PIN3 (GRN), LED7-1-7.PIN3 (GRN), LED8-1-1.PIN3 (GRN), LED8-1-2.PIN3 (GRN), LED8-1-3.PIN3 (GRN), LED9-1-1.PIN3 (GRN), R36.2
U1CS5: LED7-1-5.PIN4 (BLU), LED7-1-6.PIN4 (BLU), LED7-1-7.PIN4 (BLU), LED8-1-1.PIN4 (BLU), LED8-1-2.PIN4 (BLU), LED8-1-3.PIN4 (BLU), LED9-1-1.PIN4 (BLU), R35.2
U1CS6: LED7-1-5.PIN2 (RED), LED7-1-6.PIN2 (RED), LED7-1-7.PIN2 (RED), LED8-1-1.PIN2 (RED), LED8-1-2.PIN2 (RED), LED8-1-3.PIN2 (RED), LED9-1-1.PIN2 (RED), R34.2
U1CS7: LED6-1-1.PIN3 (GRN), LED6-1-2.PIN3 (GRN), LED6-1-3.PIN3 (GRN), LED6-1-4.PIN3 (GRN), LED6-1-5.PIN3 (GRN), LED7-1-1.PIN3 (GRN), LED7-1-2.PIN3 (GRN), LED7-1-3.PIN3 (GRN), LED7-1-4.PIN3 (GRN), R33.2
U1CS8: LED6-1-1.PIN4 (BLU), LED6-1-2.PIN4 (BLU), LED6-1-3.PIN4 (BLU), LED6-1-4.PIN4 (BLU), LED6-1-5.PIN4 (BLU), LED7-1-1.PIN4 (BLU), LED7-1-2.PIN4 (BLU), LED7-1-3.PIN4 (BLU), LED7-1-4.PIN4 (BLU), R32.2
U1CS9: LED6-1-1.PIN2 (RED), LED6-1-2.PIN2 (RED), LED6-1-3.PIN2 (RED), LED6-1-4.PIN2 (RED), LED6-1-5.PIN2 (RED), LED7-1-1.PIN2 (RED), LED7-1-2.PIN2 (RED), LED7-1-3.PIN2 (RED), LED7-1-4.PIN2 (RED), R31.2
U1CS10: LED5-1-8.PIN3 (GRN), LED5-1-9.PIN3 (GRN), LED5-1-10.PIN3 (GRN), LED5-1-11.PIN3 (GRN), LED5-1-12.PIN3 (GRN), LED6-1-6.PIN3 (GRN), LED6-1-7.PIN3 (GRN), LED6-1-8.PIN3 (GRN), LED6-1-9.PIN3 (GRN), R30.2
U1CS11: LED5-1-8.PIN4 (BLU), LED5-1-9.PIN4 (BLU), LED5-1-10.PIN4 (BLU), LED5-1-11.PIN4 (BLU), LED5-1-12.PIN4 (BLU), LED6-1-6.PIN4 (BLU), LED6-1-7.PIN4 (BLU), LED6-1-8.PIN4 (BLU), LED6-1-9.PIN4 (BLU), R29.2
U1CS12: LED5-1-8.PIN2 (RED), LED5-1-9.PIN2 (RED), LED5-1-10.PIN2 (RED), LED5-1-11.PIN2 (RED), LED5-1-12.PIN2 (RED), LED6-1-6.PIN2 (RED), LED6-1-7.PIN2 (RED), LED6-1-8.PIN2 (RED), LED6-1-9.PIN2 (RED), R28.2
U1CS13: LED4-1-1.PIN3 (GRN), LED4-1-2.PIN3 (GRN), LED5-1-1.PIN3 (GRN), LED5-1-2.PIN3 (GRN), LED5-1-3.PIN3 (GRN), LED5-1-4.PIN3 (GRN), LED5-1-5.PIN3 (GRN), LED5-1-6.PIN3 (GRN), LED5-1-7.PIN3 (GRN), R27.2
U1CS14: LED4-1-1.PIN4 (BLU), LED4-1-2.PIN4 (BLU), LED5-1-1.PIN4 (BLU), LED5-1-2.PIN4 (BLU), LED5-1-3.PIN4 (BLU), LED5-1-4.PIN4 (BLU), LED5-1-5.PIN4 (BLU), LED5-1-6.PIN4 (BLU), LED5-1-7.PIN4 (BLU), R26.2
U1CS15: LED4-1-1.PIN2 (RED), LED4-1-2.PIN2 (RED), LED5-1-1.PIN2 (RED), LED5-1-2.PIN2 (RED), LED5-1-3.PIN2 (RED), LED5-1-4.PIN2 (RED), LED5-1-5.PIN2 (RED), LED5-1-6.PIN2 (RED), LED5-1-7.PIN2 (RED), R25.2
U1CS16: LED4-1-3.PIN3 (GRN), LED4-1-4.PIN3 (GRN), LED4-1-5.PIN3 (GRN), LED4-1-6.PIN3 (GRN), LED4-1-7.PIN3 (GRN), LED4-1-8.PIN3 (GRN), LED4-1-9.PIN3 (GRN), LED4-1-10.PIN3 (GRN), LED4-1-11.PIN3 (GRN), R24.2
U1CS17: LED4-1-3.PIN4 (BLU), LED4-1-4.PIN4 (BLU), LED4-1-5.PIN4 (BLU), LED4-1-6.PIN4 (BLU), LED4-1-7.PIN4 (BLU), LED4-1-8.PIN4 (BLU), LED4-1-9.PIN4 (BLU), LED4-1-10.PIN4 (BLU), LED4-1-11.PIN4 (BLU), R23.2
U1CS18: LED4-1-3.PIN2 (RED), LED4-1-4.PIN2 (RED), LED4-1-5.PIN2 (RED), LED4-1-6.PIN2 (RED), LED4-1-7.PIN2 (RED), LED4-1-8.PIN2 (RED), LED4-1-9.PIN2 (RED), LED4-1-10.PIN2 (RED), LED4-1-11.PIN2 (RED), R22.2
U1CS19: LED3-1-12.PIN3 (GRN), LED3-1-13.PIN3 (GRN), LED3-1-14.PIN3 (GRN), LED3-1-15.PIN3 (GRN), LED3-1-16.PIN3 (GRN), LED3-1-17.PIN3 (GRN), LED4-1-12.PIN3 (GRN), LED4-1-13.PIN3 (GRN), LED4-1-14.PIN3 (GRN), R21.2
U1CS20: LED3-1-12.PIN4 (BLU), LED3-1-13.PIN4 (BLU), LED3-1-14.PIN4 (BLU), LED3-1-15.PIN4 (BLU), LED3-1-16.PIN4 (BLU), LED3-1-17.PIN4 (BLU), LED4-1-12.PIN4 (BLU), LED4-1-13.PIN4 (BLU), LED4-1-14.PIN4 (BLU), R20.2
U1CS21: LED3-1-12.PIN2 (RED), LED3-1-13.PIN2 (RED), LED3-1-14.PIN2 (RED), LED3-1-15.PIN2 (RED), LED3-1-16.PIN2 (RED), LED3-1-17.PIN2 (RED), LED4-1-12.PIN2 (RED), LED4-1-13.PIN2 (RED), LED4-1-14.PIN2 (RED), R19.2
U1CS22: LED3-1-3.PIN3 (GRN), LED3-1-4.PIN3 (GRN), LED3-1-5.PIN3 (GRN), LED3-1-6.PIN3 (GRN), LED3-1-7.PIN3 (GRN), LED3-1-8.PIN3 (GRN), LED3-1-9.PIN3 (GRN), LED3-1-10.PIN3 (GRN), LED3-1-11.PIN3 (GRN), R18.2
U1CS23: LED3-1-3.PIN4 (BLU), LED3-1-4.PIN4 (BLU), LED3-1-5.PIN4 (BLU), LED3-1-6.PIN4 (BLU), LED3-1-7.PIN4 (BLU), LED3-1-8.PIN4 (BLU), LED3-1-9.PIN4 (BLU), LED3-1-10.PIN4 (BLU), LED3-1-11.PIN4 (BLU), R17.2
U1CS24: LED3-1-3.PIN2 (RED), LED3-1-4.PIN2 (RED), LED3-1-5.PIN2 (RED), LED3-1-6.PIN2 (RED), LED3-1-7.PIN2 (RED), LED3-1-8.PIN2 (RED), LED3-1-9.PIN2 (RED), LED3-1-10.PIN2 (RED), LED3-1-11.PIN2 (RED), R16.2
U1CS25: LED2-1-1.PIN3 (GRN), LED2-1-2.PIN3 (GRN), LED2-1-3.PIN3 (GRN), LED2-1-4.PIN3 (GRN), LED2-1-5.PIN3 (GRN), LED2-1-6.PIN3 (GRN), LED2-1-7.PIN3 (GRN), LED3-1-1.PIN3 (GRN), LED3-1-2.PIN3 (GRN), R15.2
U1CS26: LED2-1-1.PIN4 (BLU), LED2-1-2.PIN4 (BLU), LED2-1-3.PIN4 (BLU), LED2-1-4.PIN4 (BLU), LED2-1-5.PIN4 (BLU), LED2-1-6.PIN4 (BLU), LED2-1-7.PIN4 (BLU), LED3-1-1.PIN4 (BLU), LED3-1-2.PIN4 (BLU), R14.2
U1CS27: LED2-1-1.PIN2 (RED), LED2-1-2.PIN2 (RED), LED2-1-3.PIN2 (RED), LED2-1-4.PIN2 (RED), LED2-1-5.PIN2 (RED), LED2-1-6.PIN2 (RED), LED2-1-7.PIN2 (RED), LED3-1-1.PIN2 (RED), LED3-1-2.PIN2 (RED), R13.2
U1CS28: LED2-1-8.PIN3 (GRN), LED2-1-9.PIN3 (GRN), LED2-1-10.PIN3 (GRN), LED2-1-11.PIN3 (GRN), LED2-1-12.PIN3 (GRN), LED2-1-13.PIN3 (GRN), LED2-1-14.PIN3 (GRN), LED2-1-15.PIN3 (GRN), LED2-1-16.PIN3 (GRN), R12.2
U1CS29: LED2-1-8.PIN4 (BLU), LED2-1-9.PIN4 (BLU), LED2-1-10.PIN4 (BLU), LED2-1-11.PIN4 (BLU), LED2-1-12.PIN4 (BLU), LED2-1-13.PIN4 (BLU), LED2-1-14.PIN4 (BLU), LED2-1-15.PIN4 (BLU), LED2-1-16.PIN4 (BLU), R11.2
U1CS30: LED2-1-8.PIN2 (RED), LED2-1-9.PIN2 (RED), LED2-1-10.PIN2 (RED), LED2-1-11.PIN2 (RED), LED2-1-12.PIN2 (RED), LED2-1-13.PIN2 (RED), LED2-1-14.PIN2 (RED), LED2-1-15.PIN2 (RED), LED2-1-16.PIN2 (RED), R10.2
U1CS31: LED1-1-19.PIN3 (GRN), LED1-1-20.PIN3 (GRN), LED1-1-21.PIN3 (GRN), LED1-1-22.PIN3 (GRN), LED1-1-23.PIN3 (GRN), LED2-1-17.PIN3 (GRN), LED2-1-18.PIN3 (GRN), LED2-1-19.PIN3 (GRN), LED2-1-20.PIN3 (GRN), R9.2
U1CS32: LED1-1-19.PIN4 (BLU), LED1-1-20.PIN4 (BLU), LED1-1-21.PIN4 (BLU), LED1-1-22.PIN4 (BLU), LED1-1-23.PIN4 (BLU), LED2-1-17.PIN4 (BLU), LED2-1-18.PIN4 (BLU), LED2-1-19.PIN4 (BLU), LED2-1-20.PIN4 (BLU), R8.2
U1CS33: LED1-1-19.PIN2 (RED), LED1-1-20.PIN2 (RED), LED1-1-21.PIN2 (RED), LED1-1-22.PIN2 (RED), LED1-1-23.PIN2 (RED), LED2-1-17.PIN2 (RED), LED2-1-18.PIN2 (RED), LED2-1-19.PIN2 (RED), LED2-1-20.PIN2 (RED), R7.2
U1CS34: LED1-1-10.PIN3 (GRN), LED1-1-11.PIN3 (GRN), LED1-1-12.PIN3 (GRN), LED1-1-13.PIN3 (GRN), LED1-1-14.PIN3 (GRN), LED1-1-15.PIN3 (GRN), LED1-1-16.PIN3 (GRN), LED1-1-17.PIN3 (GRN), LED1-1-18.PIN3 (GRN), R6.2
U1CS35: LED1-1-10.PIN4 (BLU), LED1-1-11.PIN4 (BLU), LED1-1-12.PIN4 (BLU), LED1-1-13.PIN4 (BLU), LED1-1-14.PIN4 (BLU), LED1-1-15.PIN4 (BLU), LED1-1-16.PIN4 (BLU), LED1-1-17.PIN4 (BLU), LED1-1-18.PIN4 (BLU), R5.2
U1CS36: LED1-1-10.PIN2 (RED), LED1-1-11.PIN2 (RED), LED1-1-12.PIN2 (RED), LED1-1-13.PIN2 (RED), LED1-1-14.PIN2 (RED), LED1-1-15.PIN2 (RED), LED1-1-16.PIN2 (RED), LED1-1-17.PIN2 (RED), LED1-1-18.PIN2 (RED), R4.2
U1CS37: LED1-1-1.PIN3 (GRN), LED1-1-2.PIN3 (GRN), LED1-1-3.PIN3 (GRN), LED1-1-4.PIN3 (GRN), LED1-1-5.PIN3 (GRN), LED1-1-6.PIN3 (GRN), LED1-1-7.PIN3 (GRN), LED1-1-8.PIN3 (GRN), LED1-1-9.PIN3 (GRN), R3.2
U1CS38: LED1-1-1.PIN4 (BLU), LED1-1-2.PIN4 (BLU), LED1-1-3.PIN4 (BLU), LED1-1-4.PIN4 (BLU), LED1-1-5.PIN4 (BLU), LED1-1-6.PIN4 (BLU), LED1-1-7.PIN4 (BLU), LED1-1-8.PIN4 (BLU), LED1-1-9.PIN4 (BLU), R2.2
U1CS39: LED1-1-1.PIN2 (RED), LED1-1-2.PIN2 (RED), LED1-1-3.PIN2 (RED), LED1-1-4.PIN2 (RED), LED1-1-5.PIN2 (RED), LED1-1-6.PIN2 (RED), LED1-1-7.PIN2 (RED), LED1-1-8.PIN2 (RED), LED1-1-9.PIN2 (RED), R1.2
U1SW1: LED1-1-1.PIN1 (A), LED1-1-10.PIN1 (A), LED1-1-19.PIN1 (A), LED2-1-7.PIN1 (A), LED2-1-16.PIN1 (A), LED3-1-3.PIN1 (A), LED3-1-12.PIN1 (A), LED4-1-2.PIN1 (A), LED4-1-11.PIN1 (A), LED5-1-8.PIN1 (A), LED6-1-5.PIN1 (A), LED7-1-5.PIN1 (A), U1.16 (SW1)
U1SW2: LED1-1-2.PIN1 (A), LED1-1-11.PIN1 (A), LED1-1-20.PIN1 (A), LED2-1-6.PIN1 (A), LED2-1-15.PIN1 (A), LED3-1-4.PIN1 (A), LED3-1-13.PIN1 (A), LED4-1-1.PIN1 (A), LED4-1-10.PIN1 (A), LED5-1-9.PIN1 (A), LED6-1-4.PIN1 (A), LED7-1-6.PIN1 (A), U1.17 (SW2)
U1SW3: LED1-1-3.PIN1 (A), LED1-1-12.PIN1 (A), LED1-1-21.PIN1 (A), LED2-1-5.PIN1 (A), LED2-1-14.PIN1 (A), LED3-1-5.PIN1 (A), LED3-1-14.PIN1 (A), LED4-1-9.PIN1 (A), LED5-1-1.PIN1 (A), LED5-1-10.PIN1 (A), LED6-1-3.PIN1 (A), LED7-1-7.PIN1 (A), U1.18 (SW3)
U1SW4: LED1-1-4.PIN1 (A), LED1-1-13.PIN1 (A), LED1-1-22.PIN1 (A), LED2-1-4.PIN1 (A), LED2-1-13.PIN1 (A), LED3-1-6.PIN1 (A), LED3-1-15.PIN1 (A), LED4-1-8.PIN1 (A), LED5-1-2.PIN1 (A), LED5-1-11.PIN1 (A), LED6-1-2.PIN1 (A), LED8-1-3.PIN1 (A), U1.19 (SW4)
U1SW5: LED1-1-5.PIN1 (A), LED1-1-14.PIN1 (A), LED1-1-23.PIN1 (A), LED2-1-3.PIN1 (A), LED2-1-12.PIN1 (A), LED3-1-7.PIN1 (A), LED3-1-16.PIN1 (A), LED4-1-7.PIN1 (A), LED5-1-3.PIN1 (A), LED5-1-12.PIN1 (A), LED6-1-1.PIN1 (A), LED8-1-2.PIN1 (A), U1.20 (SW5)
U1SW6: LED1-1-6.PIN1 (A), LED1-1-15.PIN1 (A), LED2-1-2.PIN1 (A), LED2-1-11.PIN1 (A), LED2-1-20.PIN1 (A), LED3-1-8.PIN1 (A), LED3-1-17.PIN1 (A), LED4-1-6.PIN1 (A), LED5-1-4.PIN1 (A), LED6-1-9.PIN1 (A), LED7-1-1.PIN1 (A), LED8-1-1.PIN1 (A), U1.21 (SW6)
U1SW7: LED1-1-7.PIN1 (A), LED1-1-16.PIN1 (A), LED2-1-1.PIN1 (A), LED2-1-10.PIN1 (A), LED2-1-19.PIN1 (A), LED3-1-9.PIN1 (A), LED4-1-5.PIN1 (A), LED4-1-14.PIN1 (A), LED5-1-5.PIN1 (A), LED6-1-8.PIN1 (A), LED7-1-2.PIN1 (A), LED9-1-1.PIN1 (A), U1.22 (SW7)
U1SW8: LED1-1-8.PIN1 (A), LED1-1-17.PIN1 (A), LED2-1-9.PIN1 (A), LED2-1-18.PIN1 (A), LED3-1-1.PIN1 (A), LED3-1-10.PIN1 (A), LED4-1-4.PIN1 (A), LED4-1-13.PIN1 (A), LED5-1-6.PIN1 (A), LED6-1-7.PIN1 (A), LED7-1-3.PIN1 (A), U1.23 (SW8)
U1SW9: LED1-1-9.PIN1 (A), LED1-1-18.PIN1 (A), LED2-1-8.PIN1 (A), LED2-1-17.PIN1 (A), LED3-1-2.PIN1 (A), LED3-1-11.PIN1 (A), LED4-1-3.PIN1 (A), LED4-1-12.PIN1 (A), LED5-1-7.PIN1 (A), LED6-1-6.PIN1 (A), LED7-1-4.PIN1 (A), U1.24 (SW9)

Notes on the sheet:
LED Array Left
change these to cree UHD1110-FKA LEDs
ADDR connect to ground ADDR=00 See pg. 7 of datasheet

Notices in the files:
parts and their libraries:
SparkFun-Resistors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
